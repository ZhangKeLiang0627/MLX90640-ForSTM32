# Keil uVision project FATFS.uvprojx, settings and files
target FATFS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FATFS +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\KEY;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\FWLIB\inc;..\HARDWARE\SD;..\HARDWARE\WS2812B;..\HARDWARE\Encoder;..\HARDWARE\ST7789;..\HARDWARE\DMA;..\HARDWARE\OLED;..\TEXT;..\MLX90640_lib\headers;..\MLX90640_lib\mlx90640_lcd_dispaly
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/WS2812B/: WS2812B.c WS2812B.h
    ../HARDWARE/Encoder/: Encoder.c Encoder.h
    ../HARDWARE/ST7789/: ST7789_Init.c ST7789_Init.h lcd.c lcd.h
    ../HARDWARE/DMA/: MyDMA.c MyDMA.h
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_i2c.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group MLX90640
    ../MLX90640_lib/functions/: MLX90640_SWI2C_Driver.cpp MLX90640_API.c
    ../MLX90640_lib/headers/: MLX90640_I2C_Driver.h MLX90640_API.h
    ../MLX90640_lib/mlx90640_lcd_dispaly/: mlx90640_lcd_display.c mlx90640_lcd_display.h
